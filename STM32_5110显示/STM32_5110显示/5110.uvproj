# Keil uVision project 5110.uvproj, settings and files
target 5110 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: 5110 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: .\CMSIS;.\Driver\inc;.\Driver\src;.\StartUp;.\User
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./User/: 5110LCD.c main.c stm32f10x_it.c 5110LCD.h key.c
  group StaerUp
    ./StartUp/: startup_stm32f10x_md.s
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group Driver
    ./Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c
